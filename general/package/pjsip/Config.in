## general/package/pjsip/Config.in
```kconfig
config BR2_PACKAGE_PJSIP
	bool "pjsip"
	default n
	help
	  Signaling protocol (SIP) library

	  https://www.pjsip.org/
```
